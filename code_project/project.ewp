# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB; DAPLINK_VERSION=254; HID_ENDPOINT; MSC_ENDPOINT; CDC_ENDPOINT; WEBUSB_INTERFACE; WINUSB_INTERFACE; DRAG_N_DROP_SUPPORT; DAPLINK_IF; DAPLINK_BUILD_KEY=0x9B939E8F; OS_TICK=10000; INTERFACE_STM32F103XB; USE_HAL_DRIVER; STM32F103xB; DAPLINK_HIC_ID=0x97969908; __packed=__packed; DAPLINK_NO_ASSERT_FILENAMES; OS_CLOCK=72000000; BULK_ENDPOINT; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: rt-thread\include; rt-thread\components\finsh; DAPLink\source\daplink\cmsis-dap; libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc; DAPLink\source\daplink\usb2uart; packages\CMSIS-v5.0.0\RTOS2\RT-Thread\src; board\CubeMX_Config\Inc; libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include; libraries\HAL_Drivers\config; DAPLink\source\usb; libraries\HAL_Drivers; DAPLink\source\hic_hal\stm32\stm32f103xb\cmsis; DAPLink\source\cmsis-core; .; DAPLink\source\daplink; rt-thread\components\drivers\include; board; DAPLink\source\daplink\interface; packages\CMSIS-v5.0.0\CMSIS_5\CMSIS\RTOS2\Include; DAPLink\source\target; board\ports; rt-thread\libcpu\arm\cortex-m3; applications; DAPLink\source\hic_hal; DAPLink\source\daplink\drag-n-drop; rt-thread\components\drivers\usb\usbdevice; libraries\STM32F1xx_HAL\CMSIS\Include; DAPLink\source\daplink\settings; DAPLink\source\hic_hal\stm32\stm32f103xb; rt-thread\libcpu\arm\common; rt-thread\components\libc\compilers\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_usbd.c drv_common.c
  group CMSIS
    packages/CMSIS-v5.0.0/RTOS2/RT-Thread/src/: cmsis_rtthread.c os_systick.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_iar.S
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group rt_usbd
    rt-thread/components/drivers/usb/usbdevice/core/: core.c usbdevice.c
    rt-thread/components/drivers/usb/usbdevice/class/: cdc_vcom.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c
  group libc
    rt-thread/components/libc/compilers/common/: time.c
  group STM32_HAL
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_sram.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal_hcd.c
