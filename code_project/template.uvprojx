# Keil uVision project template.uvprojx, settings and files
target stm32f103xb_if (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103xb_if
  AfterMake: fromelf --bin !L --output rtthread-dap.bin
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: DAPLINK_VERSION=254, HID_ENDPOINT, MSC_ENDPOINT, CDC_ENDPOINT, WEBUSB_INTERFACE, WINUSB_INTERFACE, DRAG_N_DROP_SUPPORT,DAPLINK_IF, DAPLINK_BUILD_KEY=0x9B939E8F, OS_TICK=10000, INTERFACE_STM32F103XB, USE_HAL_DRIVER, STM32F103xB, DAPLINK_HIC_ID=0x97969908, __packed=__packed, DAPLINK_NO_ASSERT_FILENAMES, OS_CLOCK=72000000, BULK_ENDPOINT
  c misc: --gnu --c99 --no_unaligned_access --no_unaligned_access
  c include: .\packages\DAPLink\source;packages/DAPLink/source/usb;packages/DAPLink/source/daplink/cmsis-dap;packages/DAPLink/source/daplink/drag-n-drop;packages/DAPLink/source/daplink/usb2uart;packages/DAPLink/source/daplink/settings;packages/DAPLink/source/daplink/interface;packages/DAPLink/source/daplink;packages/DAPLink/source/cmsis-core;packages/DAPLink/source/hic_hal;packages/DAPLink/source/target;packages/DAPLink/source/hic_hal/stm32/stm32f103xb;packages/DAPLink/source/hic_hal/stm32/stm32f103xb/cmsis;packages/DAPLink/source/hic_hal/stm32/stm32f103xb/STM32F1xx_HAL_Driver;packages/DAPLink/source/hic_hal/stm32/stm32f103xb/STM32F1xx_HAL_Driver/Inc;packages\CMSIS-v5.0.0\CMSIS_5\CMSIS\RTOS2\Include;.\rt-thread;.\rt-thread\include;.\rt-thread\components\finsh;..\code_project;.\drivers;.\rt-thread\components\drivers;.\rt-thread\components\drivers\include;.\rt-thread\components\utilities\ulog;.\rt-thread\components\drivers\spi;.\rt-thread\components\drivers\spi\sfud\inc;.\rt-thread\components\dfs\include;.\rt-thread\components\dfs\filesystems\devfs;.\rt-thread\components\dfs\filesystems\elmfat
  asm misc: --cpreproc --cpreproc_opts=-DDAPLINK_VERSION=254,-DHID_ENDPOINT,-DMSC_ENDPOINT,-DCDC_ENDPOINT,-DWEBUSB_INTERFACE,-DWINUSB_INTERFACE,-DDRAG_N_DROP_SUPPORT,-DDAPLINK_IF,-DDAPLINK_BUILD_KEY=0x9B939E8F,-DOS_TICK=10000,-DINTERFACE_STM32F103XB,-DUSE_HAL_DRIVER,-DSTM32F103xB,-DDAPLINK_HIC_ID=0x97969908,-D__packed=__packed,-DDAPLINK_NO_ASSERT_FILENAMES,-DOS_CLOCK=72000000,-DBULK_ENDPOINT --no_unaligned_access
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\packages\DAPLink\source\daplink.sct
  link misc: --predefine="-DDAPLINK_IF" --predefine="-I..\..\..\source\hic_hal\stm32\stm32f103xb"
  group cmsis-dap
    packages/DAPLink/source/daplink/cmsis-dap/: DAP.c DAP_queue.c DAP_vendor.c JTAG_DP.c SW_DP.c SWO.c
  group daplink_if
    packages/DAPLink/source/daplink/interface/: bootloader_update.c daplink.c dap_main.c SVC_Table.s swd_host.c swd_host_ca.c target_flash.c
    packages/DAPLink/source/daplink/: circ_buf.c cortex_m.c crc16.c crc32.c error.c flash_hal.c HardFault_Handler.c info.c sdk_stub.c util.c validation.c
  group drag-n-drop
    packages/DAPLink/source/daplink/drag-n-drop/: file_stream.c flash_decoder.c flash_intf.c flash_manager.c iap_flash_intf.c intelhex.c vfs_manager.c vfs_user.c virtual_fs.c
  group family
    packages/DAPLink/source/family/freescale/: target_reset_Kseries.c target_reset_Lseries.c target_reset_mimxrt.c target_reset_rapid_iot.c
    packages/DAPLink/source/family/nordic/: target_reset_nrf51.c target_reset_nrf52.c
    packages/DAPLink/source/family/realtek/: target_reset_realtek_rtl8195am.c
    packages/DAPLink/source/family/renesas/: target_reset_rza.c
    packages/DAPLink/source/family/ti/: target_reset_ti.c
    packages/DAPLink/source/family/toshiba/: target_reset_tz.c
    packages/DAPLink/source/family/wiznet/: target_reset_wiznet.c
  group hic_hal
    packages/DAPLink/source/hic_hal/stm32/stm32f103xb/: flash.c gpio.c read_uid.c sdk.c uart.c usb_config.c usbd_STM32F103.c
    packages/DAPLink/source/hic_hal/stm32/stm32f103xb/armcc/: startup_stm32f103xb.S
    packages/DAPLink/source/hic_hal/stm32/stm32f103xb/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
    packages/DAPLink/source/hic_hal/stm32/stm32f103xb/cmsis/: system_stm32f1xx.c
    ./packages/DAPLink/source/hic_hal/stm32/stm32f103xb/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_spi.c stm32f1xx_ll_spi.c
  group settings
    packages/DAPLink/source/daplink/settings/: settings.c settings_rom.c
  group target
    packages/DAPLink/source/target/: target_board.c target_family.c
  group usb
    packages/DAPLink/source/usb/bulk/: usbd_bulk.c
    packages/DAPLink/source/usb/cdc/: usbd_cdc_acm.c usbd_core_cdc.c
    packages/DAPLink/source/usb/: usbd_core.c
    packages/DAPLink/source/usb/hid/: usbd_core_hid.c usbd_hid.c usbd_user_hid.c
    packages/DAPLink/source/usb/msc/: usbd_core_msc.c usbd_msc.c
    packages/DAPLink/source/usb/webusb/: usbd_core_webusb.c
    packages/DAPLink/source/usb/winusb/: usbd_core_winusb.c
  group usb2uart
    packages/DAPLink/source/daplink/usb2uart/: usbd_user_cdc_acm.c
  group rtt_Applications
    ./Applications/: rtt_main.c
  group rtt_os
    drivers/: board.c
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c device.c
  group rtt_cpu
    rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group rtt_DevixeDrivers
    ./rt-thread/components/drivers/serial/: serial.c
    ./rt-thread/components/drivers/src/: waitqueue.c workqueue.c ringbuffer.c ringblk_buf.c pipe.c dataqueue.c completion.c
    ./rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ./rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group rtt_drivers
    drivers/: drv_usart.c drv_common.c
    ./drivers/: drv_spi.c spi_flash_init.c
  group rtt_CMSIS
    ./packages/CMSIS-v5.0.0/RTOS2/RT-Thread/src/: cmsis_rtthread.c os_systick.c
  group rtt_finsh
    ./rt-thread/components/finsh/: cmd.c msh_file.c msh.c shell.c
  group rtt_Filesystem
    ./rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ./rt-thread/components/dfs/filesystems/devfs/: devfs.c
    ./rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
