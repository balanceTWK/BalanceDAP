# Keil uVision project project.uvprojx, settings and files
target stm32f103xb_if (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103xb_if
  AfterMake: fromelf --bin !L --output rtthread-dap.bin
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F103xB, __packed=__packed, INTERFACE_STM32F103XB, MSC_ENDPOINT, DAPLINK_BUILD_KEY=0x9B939E8F, OS_CLOCK=72000000, DRAG_N_DROP_SUPPORT, USE_HAL_DRIVER, DAPLINK_VERSION=254, CDC_ENDPOINT, HID_ENDPOINT, DAPLINK_IF, DAPLINK_NO_ASSERT_FILENAMES, WEBUSB_INTERFACE, OS_TICK=10000, DAPLINK_HIC_ID=0x97969908, WINUSB_INTERFACE, BULK_ENDPOINT
  c misc: --gnu --c99 --no_unaligned_access --no_unaligned_access
  c include: .;rt-thread\include;Applications;drivers;drivers\config;packages\CMSIS-v5.0.0\CMSIS_5\CMSIS\RTOS2\Include;packages\CMSIS-v5.0.0\RTOS2\RT-Thread\src;packages\DAPLink\source;packages\DAPLink\source\usb;packages\DAPLink\source\daplink;packages\DAPLink\source\daplink\cmsis-dap;packages\DAPLink\source\daplink\drag-n-drop;packages\DAPLink\source\daplink\usb2uart;packages\DAPLink\source\daplink\settings;packages\DAPLink\source\daplink\interface;packages\DAPLink\source\cmsis-core;packages\DAPLink\source\target;packages\DAPLink\source\hic_hal;packages\DAPLink\source\hic_hal\stm32\stm32f103xb;packages\DAPLink\source\hic_hal\stm32\stm32f103xb\cmsis;packages\DAPLink\source\hic_hal\stm32\stm32f103xb\STM32F1xx_HAL_Driver;packages\DAPLink\source\hic_hal\stm32\stm32f103xb\STM32F1xx_HAL_Driver\Inc;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m3;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\libc\compilers\common
  asm misc: --cpreproc --cpreproc_opts=-DDAPLINK_VERSION=254,-DHID_ENDPOINT,-DMSC_ENDPOINT,-DCDC_ENDPOINT,-DWEBUSB_INTERFACE,-DWINUSB_INTERFACE,-DDRAG_N_DROP_SUPPORT,-DDAPLINK_IF,-DDAPLINK_BUILD_KEY=0x9B939E8F,-DOS_TICK=10000,-DINTERFACE_STM32F103XB,-DUSE_HAL_DRIVER,-DSTM32F103xB,-DDAPLINK_HIC_ID=0x97969908,-D__packed=__packed,-DDAPLINK_NO_ASSERT_FILENAMES,-DOS_CLOCK=72000000,-DBULK_ENDPOINT --no_unaligned_access
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\packages\DAPLink\source\daplink.sct
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    Applications/: rtt_main.c
  group Drivers
    drivers/: board.c drv_usart.c drv_spi.c drv_spi_flash.c drv_common.c
  group CMSIS
    packages/CMSIS-v5.0.0/RTOS2/RT-Thread/src/: cmsis_rtthread.c os_systick.c
  group daplink
    packages/DAPLink/source/daplink/cmsis-dap/: DAP.c DAP_queue.c DAP_vendor.c JTAG_DP.c SW_DP.c SWO.c
    packages/DAPLink/source/daplink/interface/: bootloader_update.c daplink.c dap_main.c SVC_Table.s swd_host.c swd_host_ca.c target_flash.c
    packages/DAPLink/source/daplink/: circ_buf.c cortex_m.c crc16.c crc32.c error.c flash_hal.c info.c sdk_stub.c util.c validation.c
    packages/DAPLink/source/daplink/drag-n-drop/: file_stream.c flash_decoder.c flash_intf.c flash_manager.c iap_flash_intf.c intelhex.c vfs_manager.c vfs_user.c virtual_fs.c
    packages/DAPLink/source/family/freescale/: target_reset_Kseries.c target_reset_Lseries.c target_reset_mimxrt.c target_reset_rapid_iot.c
    packages/DAPLink/source/family/nordic/: target_reset_nrf51.c target_reset_nrf52.c
    packages/DAPLink/source/family/realtek/: target_reset_realtek_rtl8195am.c
    packages/DAPLink/source/family/renesas/: target_reset_rza.c
    packages/DAPLink/source/family/ti/: target_reset_ti.c
    packages/DAPLink/source/family/toshiba/: target_reset_tz.c
    packages/DAPLink/source/family/wiznet/: target_reset_wiznet.c
    packages/DAPLink/source/hic_hal/stm32/stm32f103xb/: flash.c gpio.c read_uid.c sdk.c uart.c usb_config.c usbd_STM32F103.c
    packages/DAPLink/source/hic_hal/stm32/stm32f103xb/armcc/: startup_stm32f103xb.S
    packages/DAPLink/source/hic_hal/stm32/stm32f103xb/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_spi.c
    packages/DAPLink/source/hic_hal/stm32/stm32f103xb/cmsis/: system_stm32f1xx.c
    packages/DAPLink/source/daplink/settings/: settings.c settings_rom.c
    packages/DAPLink/source/target/: target_board.c target_family.c
    packages/DAPLink/source/usb/bulk/: usbd_bulk.c
    packages/DAPLink/source/usb/cdc/: usbd_cdc_acm.c usbd_core_cdc.c
    packages/DAPLink/source/usb/: usbd_core.c
    packages/DAPLink/source/usb/hid/: usbd_core_hid.c usbd_hid.c usbd_user_hid.c
    packages/DAPLink/source/usb/msc/: usbd_core_msc.c usbd_msc.c
    packages/DAPLink/source/usb/webusb/: usbd_core_webusb.c
    packages/DAPLink/source/usb/winusb/: usbd_core_winusb.c
    packages/DAPLink/source/daplink/usb2uart/: usbd_user_cdc_acm.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c
