# Keil uVision project stm32f103xb_if.uvprojx, settings and files
target stm32f103xb_if (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103xb_if +hex
  AfterMake: fromelf --bin !L --output rtthread-dap.bin
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: DAPLINK_VERSION=254, HID_ENDPOINT, MSC_ENDPOINT, CDC_ENDPOINT, WEBUSB_INTERFACE, WINUSB_INTERFACE, DRAG_N_DROP_SUPPORT, DAPLINK_IF, DAPLINK_BUILD_KEY=0x9B939E8F, OS_TICK=10000, INTERFACE_STM32F103XB, USE_HAL_DRIVER, STM32F103xB, DAPLINK_HIC_ID=0x97969908, __packed=__packed, DAPLINK_NO_ASSERT_FILENAMES, OS_CLOCK=72000000, BULK_ENDPOINT
  c misc: --gnu --c99 --no_unaligned_access --no_unaligned_access
  c include: ../../../source/usb;../../../source/daplink/cmsis-dap;../../../source/daplink/drag-n-drop;../../../source/daplink/usb2uart;../../../source/daplink/settings;../../../source/daplink;../../../source/daplink/interface;../../../source/cmsis-core;../../../source/hic_hal;../../../source/target;../../../source/hic_hal/stm32/stm32f103xb;../../../source/hic_hal/stm32/stm32f103xb/cmsis;../../../source/hic_hal/stm32/stm32f103xb/STM32F1xx_HAL_Driver;../../../source/hic_hal/stm32/stm32f103xb/STM32F1xx_HAL_Driver/Inc;..\..\..\source\rtos\rt-thread-3.1.3\include;..\..\..\source\rtos\rt-thread-3.1.3\packages\CMSIS-v5.0.0\CMSIS_5\CMSIS\RTOS2\Include;..\..\..\source\rtos\rt-thread-3.1.3;..\..\..\source\rtos\rt-thread-3.1.3\components\finsh;..\..\RTE\_stm32f103xb_if
  asm misc: --cpreproc --cpreproc_opts=-DDAPLINK_VERSION=254,-DHID_ENDPOINT,-DMSC_ENDPOINT,-DCDC_ENDPOINT,-DWEBUSB_INTERFACE,-DWINUSB_INTERFACE,-DDRAG_N_DROP_SUPPORT,-DDAPLINK_IF,-DDAPLINK_BUILD_KEY=0x9B939E8F,-DOS_TICK=10000,-DINTERFACE_STM32F103XB,-DUSE_HAL_DRIVER,-DSTM32F103xB,-DDAPLINK_HIC_ID=0x97969908,-D__packed=__packed,-DDAPLINK_NO_ASSERT_FILENAMES,-DOS_CLOCK=72000000,-DBULK_ENDPOINT --no_unaligned_access
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ../../../source/daplink/daplink.sct
  link misc: --predefine="-DDAPLINK_IF" --predefine="-I..\..\..\source\hic_hal\stm32\stm32f103xb"
  group cmsis-dap
    ../../../source/daplink/cmsis-dap/: DAP.c DAP_queue.c DAP_vendor.c JTAG_DP.c SW_DP.c SWO.c
  group daplink_if
    ../../../source/daplink/interface/: bootloader_update.c daplink.c main.c SVC_Table.s swd_host.c swd_host_ca.c target_flash.c
    ../../../source/daplink/: circ_buf.c cortex_m.c crc16.c crc32.c error.c flash_hal.c HardFault_Handler.c info.c sdk_stub.c util.c validation.c
  group default
    ../../../source/hic_hal/: board.h flash_blob.h flash_hal.h FlashOS.h FlashPrg.h gpio.h read_uid.h sdk.h uart.h
    ../../../source/daplink/: bootloader.h circ_buf.h compiler.h cortex_m.h crc.h daplink.h daplink_debug.h error.h info.h macro.h util.h validation.h version_git.h
    ../../../source/rtos/: cmsis_os2.h rt_Event.h rt_HAL_CM.h rt_List.h rt_Mailbox.h rt_MemBox.h rt_Mutex.h rt_Robin.h rt_Semaphore.h rt_System.h rt_Task.h rt_Time.h rt_Timer.h rt_TypeDef.h RTL.h RTX_Config.h
    ../../../source/cmsis-core/: core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ../../../source/daplink/cmsis-dap/: DAP.h DAP_queue.h debug_ca.h debug_cm.h
    ../../../source/hic_hal/stm32/stm32f103xb/: DAP_config.h daplink_addr.h IO_Config.h usb_buf.h usbreg.h
    ../../../source/daplink/drag-n-drop/: file_stream.h flash_decoder.h flash_intf.h flash_manager.h intelhex.h vfs_manager.h virtual_fs.h
    ../../../source/daplink/interface/: main.h swd_host.h tasks.h
    ../../../source/usb/: rl_usb.h usb.h usb_bulk.h usb_cdc.h usb_def.h usb_for_lib.h usb_hid.h usb_lib.h usb_msc.h usb_webusb.h usb_winusb.h usbd_cdc.h usbd_cdc_acm.h usbd_core.h usbd_core_cdc.h usbd_core_hid.h usbd_core_msc.h usbd_core_webusb.h usbd_core_winusb.h usbd_desc.h usbd_event.h usbd_hid.h usbd_hw.h usbd_lib_cdc.h usbd_lib_hid.h usbd_lib_msc.h usbd_msc.h
    ../../../source/daplink/settings/: settings.h
    ../../../source/hic_hal/stm32/stm32f103xb/cmsis/: stm32f103xb.h stm32f1xx.h system_stm32f1xx.h
    ../../../source/hic_hal/stm32/stm32f103xb/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal.h stm32f1xx_hal_cortex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h stm32f1xx_hal_usart.h
    ../../../source/hic_hal/stm32/stm32f103xb/STM32F1xx_HAL_Driver/: stm32f1xx_hal_conf.h
    ../../../source/target/: target_board.h target_config.h target_family.h target_reset.h
  group drag-n-drop
    ../../../source/daplink/drag-n-drop/: file_stream.c flash_decoder.c flash_intf.c flash_manager.c iap_flash_intf.c intelhex.c vfs_manager.c vfs_user.c virtual_fs.c
  group family
    ../../../source/family/freescale/: target_reset_Kseries.c target_reset_Lseries.c target_reset_mimxrt.c target_reset_rapid_iot.c
    ../../../source/family/nordic/: target_reset_nrf51.c target_reset_nrf52.c
    ../../../source/family/realtek/: target_reset_realtek_rtl8195am.c
    ../../../source/family/renesas/: target_reset_rza.c
    ../../../source/family/ti/: target_reset_ti.c
    ../../../source/family/toshiba/: target_reset_tz.c
    ../../../source/family/wiznet/: target_reset_wiznet.c
  group hic_hal
    ../../../source/hic_hal/stm32/stm32f103xb/: flash.c gpio.c read_uid.c sdk.c uart.c usb_config.c usbd_STM32F103.c
    ../../../source/hic_hal/stm32/stm32f103xb/armcc/: startup_stm32f103xb.S
    ../../../source/hic_hal/stm32/stm32f103xb/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
    ../../../source/hic_hal/stm32/stm32f103xb/cmsis/: system_stm32f1xx.c
  group settings
    ../../../source/daplink/settings/: settings.c settings_rom.c
  group target
    ../../../source/target/: target_board.c target_family.c
  group usb
    ../../../source/usb/bulk/: usbd_bulk.c
    ../../../source/usb/cdc/: usbd_cdc_acm.c usbd_core_cdc.c
    ../../../source/usb/: usbd_core.c
    ../../../source/usb/hid/: usbd_core_hid.c usbd_hid.c usbd_user_hid.c
    ../../../source/usb/msc/: usbd_core_msc.c usbd_msc.c
    ../../../source/usb/webusb/: usbd_core_webusb.c
    ../../../source/usb/winusb/: usbd_core_winusb.c
  group usb2uart
    ../../../source/daplink/usb2uart/: usbd_user_cdc_acm.c
  group rtos
    ../../../source/rtos/rt-thread-3.1.3/: board.c rtconfig.h
    ../../../source/rtos/rt-thread-3.1.3/packages/CMSIS-v5.0.0/RTOS2/RT-Thread/src/: cmsis_rtthread.c os_systick.c
    ../../../source/rtos/rt-thread-3.1.3/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
    ../../../source/rtos/rt-thread-3.1.3/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
    ../../../source/rtos/rt-thread-3.1.3/components/finsh/: cmd.c msh.c shell.c
  group rtos_drivers
    ../../../source/rtos/rt-thread-3.1.3/drivers/: drv_usart.c drv_common.c
software components: CMSIS:CORE 5.1.2
